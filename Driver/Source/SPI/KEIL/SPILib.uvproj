# Keil uVision project SPILib.uvproj, settings and files
target DebugRel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H26_SPI (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\Library\IPLib
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../: spi.c spiflash.c SPIGlue.c spiflash_freertos.c
target DebugRel_FreeRTOS (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_SPI_FreeRTOS (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\Library\IPLib
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __FreeRTOS__ __RAK439__
  c include: ..\..\SPI;..\..\..\Include;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\SampleCode\FreeRTOS\ARM9_N9H26
  memory RVCT9: RAM 0xf8002000 size 0x8000
