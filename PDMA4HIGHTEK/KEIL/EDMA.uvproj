# Keil uVision project EDMA.uvproj, settings and files
target DebugRel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Nuvoton_ARM9_Series Nuvoton
  cpu: IRAM(0x0-0x0) CLOCK(000000000) CPUTYPE(ARM926EJ-S)
  output: EDMA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Driver\Include;..\..\VPOST\ASIC;..\..\Driver\Include
  memory RVCT9: RAM 0x0 size 0x1
  scatter file: ..\..\Script\N9H26\N9H26K5.sct
  link misc: --entry 0
  group Src
    ../: main.c Smpl_Pdma_SPI.c standalone.c wb_init.s
    ../../Driver/Source/SPI/: spi.c
    ../../Driver/Source/EDMA/: N9H26_edma.c DrvEDMA.c
  group Lib
    ../../Library/IPLib/: N9H26_AAC.lib N9H26_ADC.lib N9H26_AES.lib N9H26_AUR.lib N9H26_BLT.lib N9H26_CRC.lib N9H26_Font_QVGA.lib N9H26_Font_VGA.lib N9H26_Font_WQVGA.lib N9H26_Font_WVGA.lib N9H26_GIANTPLUS_GPM1006D.lib N9H26_GPIO.lib N9H26_H264Codec.lib N9H26_I2C.lib N9H26_I2S.lib N9H26_JPEG.lib N9H26_KPI_2x3.lib N9H26_MSC_All.lib N9H26_MSC_All_CDROM.lib N9H26_MSC_CDROM_Only.lib N9H26_MSC_NAND.lib N9H26_MSC_NAND_CDROM.lib N9H26_MSC_NAND_SD.lib N9H26_MSC_NAND_SD_CDROM.lib N9H26_MSC_RAM.lib N9H26_MSC_RAM_CDROM.lib N9H26_MSC_SD.lib N9H26_MSC_SD_CDROM.lib N9H26_MSC_SPI.lib N9H26_MSC_SPI_CDROM.lib N9H26_PWM.lib N9H26_RF.lib N9H26_ROT.lib N9H26_RS.lib N9H26_RTC.lib N9H26_SDIO.lib N9H26_SIC.lib N9H26_SPI_FreeRTOS.lib N9H26_SPI_Secureic.lib N9H26_SPI_SPIToUART.lib N9H26_SPU.lib N9H26_SYS.lib N9H26_SYS_FreeRTOS.lib N9H26_UDC.lib N9H26_UDC_Fullspeed.lib N9H26_UDC_Highspeed.lib N9H26_VPE.lib N9H26_VPOST_FW050TFT_800x480.lib N9H26_VPOST_LCM.lib
